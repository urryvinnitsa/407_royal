# Keil uVision project royal_407.uvprojx, settings and files
target 407_royal (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,
  c misc: --no_strict --gnu
  c include: ..\inc;..\STM32F4xx_StdPeriph_Driver\inc;..\CMSIS\Include;..\CMSIS\Device\ST\STM32F4xx\Include;..\contiki;..\contiki\lib;..\contiki\sys;..\mavlink;..\mavlink\common;..\mavlink\minimal;..\W5500;..\net;..\udp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../src/: system_stm32f4xx.c
  group MDK-ARM
    ./: startup_stm32f4xx.s
  group User
    ../src/: main.c stm32f4xx_it.c buttons.c leds.c adc_j.c
    ../inc/: buttons.h hard_config.h main.h leds.h adc_j.h
  group STM32F4xx_StdPeriph
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group contiki
    ../contiki/: contiki.h contiki-conf.h contiki-default-conf.h contiki-lib.h contiki-net.h contiki-version.h nvic.h rtimer-arch.h
    ../contiki/lib/: list.c memb.c random.c
    ../contiki/sys/: autostart.c clock.c ctimer.c etimer.c process.c rtimer.c timer.c
  group mavlink
    ../mavlink/: checksum.h mavlink_conversions.h mavlink_get_info.h mavlink_helpers.h mavlink_sha256.h mavlink_types.h protocol.h
  group W5500
    ../W5500/: w5500.c wizchip_conf.c w5500.h wizchip_conf.h
  group net
    ../net/: dhcp.c socket.c spi.c dhcp.h socket.h spi.h
  group udp
    ../udp/: task_udp.c task_udp.h
software components: CMSIS:CORE 6.0.0
